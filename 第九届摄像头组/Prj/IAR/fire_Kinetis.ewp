# IAR project fire_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_Kinetis.hex
  ILINK.IlinkOutputFile: fire_Kinetis.out
configuration FX15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
configuration DZ10_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: main.c MK60_it.c sbq.c sbq.h
  group Board
    ../../Board/src/: FIRE_ASCII.c FIRE_BMP.c fire_img2sd.c FIRE_key.c FIRE_key_event.c FIRE_LCD.c FIRE_LCD_CH.c FIRE_LCD_ILI9341.c FIRE_LCD_ST7735R.c FIRE_LCD_ST7735S.c FIRE_LED.C FIRE_MK60_conf.c FIRE_MMA7455.c FIRE_NRF24L0.c FIRE_NRF24L0_MSG.c FIRE_OV7725_Eagle.c FIRE_OV7725_Wolf.c FIRE_RTC_count.C FIRE_SCCB.c fire_sd_app.c FIRE_TSL1401.c FIRE_UI_VAR.c
    ../../Board/inc/: FIRE_MK60_conf.h
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM4l_math.a
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
