# IAR project vcan_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
configuration FX15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
configuration DZ10_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: main.c MK60_conf.c MK60_it.c
    ../../App/Inc/: MK60_conf.h MK60_it.h OLED.c oled.h PORT_cfg.h
  group Board
    ../../Board/src/: VCAN_key.c VCAN_LED.C
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_DWT.c MK60_flash.c MK60_gpio.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
